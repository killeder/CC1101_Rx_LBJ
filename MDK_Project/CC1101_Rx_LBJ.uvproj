# Keil uVision project CC1101_Rx_LBJ.uvproj, settings and files
target CC1101_Rx_LBJ (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CC1101_Rx_LBJ
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,POCSAG_DEBUG_MSG_ON,RADIO_DEBUG_MSG_ON
  c misc: --c99
  c include: ..\App_User;..\App_Utils;..\Hardware;..\FirmwareLib;..\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group App/User
    ../App_User/: main.c system_utils.c CC1101_Rx_LBJ.h
  group App/Utils
    ../App_Utils/: bit.h delay.c POCSAG_ParseLBJ.c
  group Hardware
    ../Hardware/: Hardware.h HW_GPIO.c HW_RADIO_CC1101.c HW_TIM.c HW_USART.c HW_IIC_SoftSimulate.c HW_OLED_Font.c HW_SSD1306_OLED.c
  group FirmwareLib
    ../FirmwareLib/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    ../CMSIS/: core_cm3.c startup_stm32f10x_hd.s stm32f10x_conf.h system_stm32f10x.c
